# Keil uVision project BMS_Unified.uvprojx, settings and files
target BMS_24S100AQ (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32WB436RFQ7 Nationstech
  pack: Nationstech.N32WB43x_DFP.0.2.1
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: H24S100A4TA_V1017 +hex
  AfterMake: fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: n32wb43x, USE_STDPERIPH_DRIVER, BMS_MODEL=MODEL_24S100AQ
  c include: ..\inc;..\..\firmware\CMSIS\core;..\..\firmware\CMSIS\device;..\..\firmware\n32wb43x_std_periph_driver\inc;..\bsp\inc;..\ble
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x1c000
  memory RVCT9: RAM 0x20004000 size 0x8000
  group STARTUP
    ../../firmware/CMSIS/device/startup/: startup_n32wb43x.s
  group CMSIS
    ../../firmware/CMSIS/device/: system_n32wb43x.c
  group FWLB
    ../../firmware/n32wb43x_std_periph_driver/src/: misc.c n32wb43x_adc.c n32wb43x_can.c n32wb43x_comp.c n32wb43x_crc.c n32wb43x_dac.c n32wb43x_dbg.c n32wb43x_dma.c n32wb43x_exti.c n32wb43x_flash.c n32wb43x_gpio.c n32wb43x_i2c.c n32wb43x_iwdg.c n32wb43x_lcd.c n32wb43x_lprcnt.c n32wb43x_lptim.c n32wb43x_lpuart.c n32wb43x_opamp.c n32wb43x_pwr.c n32wb43x_rcc.c n32wb43x_rtc.c n32wb43x_spi.c n32wb43x_tim.c n32wb43x_usart.c n32wb43x_wwdg.c
  group USER
    ../src/: main.c n32wb43x_it.c
    ../bsp/inc/: bms_config.h
  group BSP
    ../bsp/src/: Port.c time_config.c DVC1124.c Temperature.c Protection.c App.c CrcCfg.c MemoryModule.c ModbusPro.c Soc.c software_i2c.c Usart_Com.c User_Can_Config.c SifModule.c TimeModule.c spi_flash.c
  group BLE
    ../ble/: app_flash.c app_proto_cmd.c app_proto_cmn.c app_proto_evt.c app_uart.c app_user_svc0.c ble.c app_io.c
target BMS_17S100AQ (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: N32WB436RFQ7 Nationstech
  pack: Nationstech.N32WB43x_DFP.0.2.1
  cpu: as above
  output: 17S100AQ +hex
  AfterMake: fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: n32wb43x, USE_STDPERIPH_DRIVER, BMS_MODEL=MODEL_17S100AQ
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x1c000
  memory RVCT9: RAM 0x20004000 size 0x8000
